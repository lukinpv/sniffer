# IAR project Project.ewp, settings and files
configuration STM32F429I_DISCO_MB1075 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F429xx; USE_STM32F429I_DISCO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\STM32CubeF4\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\STM32CubeF4\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\STM32CubeF4\Drivers\BSP\STM32F429I-Discovery; ..\..\STM32CubeF4\Middlewares\ST\STemWin\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c zb_mrf24j40.c
  group Doc
    ../../: README.md
  group Drivers/BSP/Components
    ../../STM32CubeF4/Drivers/BSP/Components/ili9341/: ili9341.c
    ../../STM32CubeF4/Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/BSP/STM324x9I_DISCO
    ../../STM32CubeF4/Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_io.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c stm32f429i_discovery_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../STM32CubeF4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_ll_fmc.c
  group Middlewares/STemWin/Config
    ../../STM32CubeF4/Middlewares/ST/STemWin/OS/: GUI_X.c
    ../Src/: GUIConf.c LCDConf_stm32f429i_disco_MB1075.c
  group Middlewares/STemWin/Lib
    ../../STM32CubeF4/Middlewares/ST/STemWin/Lib/: STemWin528_CM4_IAR.a
